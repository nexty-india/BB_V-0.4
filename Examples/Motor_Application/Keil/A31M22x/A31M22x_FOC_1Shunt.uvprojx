# Keil uVision project A31M22x_FOC_1Shunt.uvprojx, settings and files
target A31M22x_FOC_1Shunt (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: A31M22x_FOC_1Shunt +hex
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __NO_EMBEDDED_ASM __DEF_A31M22x__ ONE_SHUNT
  c include: ..\..\..\..\Core\CMSIS\Cortex_M0P\Include;..\..\..\..\Core\Device\ABOV\A31M22x\Include;..\..\..\..\Drivers\A31M22x\include;..\..\..\Motor_Application;..\..\User Files\inc;..\A31M22x
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application
    ../../: MotorDriverLayer_A31M22x.c
    ./: BHARAT_BIJLEEE.c
  group CMSIS-CM0P
    ../../../../Core/Device/ABOV/A31M22x/source/: a31m22x_system.c
  group Drivers
    ../../../../Drivers/A31M22x/source/: A31M22x_adc.c a31m22x_mpwm.c a31m22x_pcu.c a31m22x_scu.c a31m22x_spi.c a31m22x_timer.c a31m22x_uart.c a31m22x_wdt.c a31m22x_cfmc.c a31m22x_dma.c
    ../../: A31M22x_initclock.c
  group Main
    ../../: main.c
  group Startup
    ../../../../Core/Device/ABOV/A31M22x/source/ARM/: a31m22x_startup_arm.s
  group UserFiles
    ./: user_timer.c Bharat_Bijlee.h user_statemachine.c user_Switch.c Modbus_Comm.c NXP_comm_uart.c Analog_Pwm_Output.c Digital_Pwm_Output.c Modbus_Holding_Register.c Application_Input_Register.c Application_Holding_Register.c Modbus_Error.c DI1_Status.c AI1_Sensor_Status.c PID_Sensor_Status.c MODBUS_Status.c Fault_Status.c Flash_Writing.c Default_Values.c Relay_Status.c Suppression_Setting.c
